#include <Wire.h>
#include "MAX30100_PulseOximeter.h"

int patient_count = 3;
String mySSID = "Its ours";      
String myPWD = "qwerty12345"; 
String myAPI[] = {"LF1CDLHV36HOKUZ0", "5ENLILCSAWYEA6EF", "MJQE8157RMDV3RCK"};   
String myHOST = "api.thingspeak.com";
String myPORT = "80"; 
String myFIELD1 = "field1"; 
String myFIELD2 = "field2"; 
String myFIELD3 = "field3"; 
String myFIELD4 = "field4"; 

#define temp_pin A1
#define PERIOD 1000

float avg_body_temp[] = {0, 0, 0};
float avg_pulse_rate[] = {0, 0, 0};
float avg_SpO2[] = {0, 0, 0};
int panic[] = {0, 0, 0};
int panic_button[] = {8, 9, 10};
long count[] = {0, 0, 0};
long avg_count;

PulseOximeter pox;
unsigned long firstMillis;
unsigned long secMillis = 0;
uint32_t ts = 0;

void setup()
{
  Serial.begin(115200);   
  pinMode(temp_pin, INPUT);    
  for(int i = 0; i < patient_count; i++)
    pinMode(panic_button[i], INPUT);   
  espData("AT+CWMODE=1", 1000);                  
  espData("AT+CWJAP=\""+ mySSID +"\",\""+ myPWD +"\"", 1000); 
  pox.begin(); 
  pox.setIRLedCurrent(MAX30100_LED_CURR_7_6MA);
  pox.setOnBeatDetectedCallback(onBeatDetected);
}

void loop()
{
  pox.update();
  firstMillis = millis();
  if(firstMillis - secMillis <= 20000)
  {
    if(millis() - ts > PERIOD)
    {
      ++avg_count;
      int ind = avg_count % patient_count;
      ++count[ind];
      avg_body_temp[ind] = ((avg_body_temp[ind] * (count[ind]-1)) + calc_body_temp()) / count[ind];
      avg_pulse_rate[ind] = ((avg_pulse_rate[ind] * (count[ind]-1)) + pox.getHeartRate()) / count[ind];
      avg_SpO2[ind] = ((avg_SpO2[ind] * (count[ind]-1)) + pox.getSpO2()) / count[ind];
      ts = millis();
    }
  } 
  else
  {
    for(int i = 0; i < patient_count; i++)
    {
      if(avg_pulse_rate[i] != 0 && avg_SpO2[i] != 0)
      {
        avg_body_temp[i] = round(avg_body_temp[i]);
        avg_pulse_rate[i] = round(avg_pulse_rate[i]);
        avg_SpO2[i] = round(avg_SpO2[i]);
        panic[i] = digitalRead(panic_button[i]);

        String sendData = "GET /update?api_key=" + myAPI[i] + "&" + myFIELD1 + "=" + String(avg_body_temp[i]) + "&" + myFIELD2 + "=" + String(avg_pulse_rate[i]) + "&" + myFIELD3 + "=" + String(avg_SpO2[i]) + "&" + myFIELD4 + "=" + String(panic[i]);
        disp_in_site(sendData);
      }
    
      count[i] = 0;
      avg_body_temp[i] = 0;
      avg_pulse_rate[i] = 0;
      avg_SpO2[i] = 0;
    }
    secMillis = firstMillis;
  }
}



String espData(String command, const int timeout)
{
  String response = "";
  Serial.println(command);
  long int t = millis();
  while((t + timeout) > millis())
  {
    while (Serial.available())
    {
      char c = Serial.read(); 
      response += c;
    }
  }
  return response;
}

void disp_in_site(String data)
{  
  espData("AT+CIPMUX=1", 1000);       
  espData("AT+CIPSTART=0,\"TCP\",\""+ myHOST +"\","+ myPORT, 1000);
  espData("AT+CIPSEND=0," +String(data.length()+4),1000);
  Serial.println(data);
  espData("AT+CIPCLOSE=0",1000);
}

float calc_body_temp()
{
  return (analogRead(temp_pin) * 0.48828125) - 28;
}

void onBeatDetected()
{
  
}
